# Keil uVision project 1_GPIO.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.4.5.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ  FPU3(SFPU)  CLOCK(12000000) ELITTLE
  output: 1_GPIO +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=6
  c misc: @./via/rasc_armclang.via
  c include: .\Int;.\APP;.\Driver;.\Com
  asm misc: --via=./via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group APP
    ./APP/: APP.c dm43x0_Task.c stepper_Task.c imu_Task.c key_Task.c display_Task.c
  group Int
    ./Int/: Int_e2prom.c Int_motor.c dm4310_ctrl.c dm4310_drv.c Int_mpu6500.c Int_electric.c
  group Driver
    ./Driver/: canfd0.c canfd1.c debug_uart7.c gpt_pwm.c KEY.c scl_i2c4.c SysTick.c uart5.c i2c2.c spi1.c uart3.c
  group Com
    ./Com/: types.c IMU.c kalman.c PID.c robot_arm.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c hal_warmstart.c
software components: Flex Software:RA Configuration 1.0.0
